options:
  parameters:
    author: Aaron Heller
    generate_options: qt_gui
    id: wspr_tx
    output_language: python
    title: wspr-tx
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: '"+14 dB RX"'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: dial_frequency
  id: variable_qtgui_chooser
  parameters:
    labels: '["10m", "15m", "20m"]'
    num_opts: '0'
    options: '[28124.6e3,  21094.6e3, 14095.6e3]'
    type: real
    value: 28124.6e3
  states: {}
- name: display
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    maxFreqHz: 30e6
    minFreqHz: 1e6
    value: dial_frequency
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: Fraction(int(samp_rate_rf), int(samp_rate))
  states: {}
- name: mod_source
  id: variable_qtgui_chooser
  parameters:
    labels: '["file", "0", "1500"]'
    num_opts: '0'
    options: '[0, 1, 2]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rf_freq_offset
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '47'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate_rf
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: rf_freq_offset
    sample_rate: samp_rate_rf
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (1/2)**(1/2)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_source
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_rf
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/heller/dev/wspr/wspr-iq.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rf
    fc: dial_frequency - rf_freq_offset
    fftsize: '16384'
    grid: 'True'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    autoscale: 'False'
    bins: '101'
    grid: 'True'
    nconnections: '2'
    size: 1<<12
    type: float
    xmax: '1.5'
    xmin: '-1.5'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rf
    fc: rf_freq_offset
    fftsize: '1024'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: interpolation_rate.denominator
    fbw: '0.25'
    interp: interpolation_rate.numerator
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: dial_frequency -rf_freq_offset
    samp_rate: samp_rate_rf
    type: fc32
    vga: rf_gain
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_selector_0, '2']
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
