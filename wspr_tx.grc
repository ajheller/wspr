options:
  parameters:
    author: Aaron Heller
    generate_options: qt_gui
    id: wspr_tx
    output_language: python
    title: wspr-tx
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: '"+14 dB RX"'
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: dial_frequency
  id: variable_qtgui_chooser
  parameters:
    labels: '["10m", "15m", "20m"]'
    num_opts: '0'
    options: '[28124.6e3,  21094.6e3, 14095.6e3]'
    type: real
    value: 28124.6e3
  states: {}
- name: display
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    maxFreqHz: 30e6
    minFreqHz: 1e6
    value: dial_frequency
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: samp_rate_rf/samp_rate
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_rf/(interpolation_rate*2)
    gain: interpolation_rate
    samp_rate: samp_rate_rf
    width: samp_rate_rf/(interpolation_rate*4)
    win: window.WIN_HANN
  states: {}
- name: mod_source
  id: variable_qtgui_chooser
  parameters:
    labels: '["file", "0", "1500"]'
    num_opts: '0'
    options: '[0, 1, 2]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: rf_freq_offset
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '47'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate_rf
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_correctiq_man_0
  id: blocks_correctiq_man
  parameters:
    imag: '0.0'
    real: '0.0'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: rf_freq_offset
    sample_rate: samp_rate_rf
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod_source
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_rf
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wspr.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(interpolation_rate)
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rf
    fc: rf_freq_offset
    fftsize: '1024'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: dial_frequency -rf_freq_offset
    samp_rate: samp_rate_rf
    type: fc32
    vga: rf_gain
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_selector_0, '2']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_selector_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [interp_fir_filter_xxx_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
